* Sallen-Key High-Pass Filter
* Parameters: R1, R2, C1, C2
* Interface: in, out
* Second-order high-pass filter with unity gain

C1 in 2 C1
C2 2 3 C2
R1 2 out R1
R2 3 0 R2
IOP 3 0 out

* Inverting Amplifier
* Parameters: R1, R2
* Interface: in, out
* Gain = -R2/R1

R1 in 2 R1
R2 2 out R2
IOP 2 0 out

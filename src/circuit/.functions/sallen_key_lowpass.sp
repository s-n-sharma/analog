* Sallen-Key Low-Pass Filter
* Parameters: R1, R2, C1, C2
* Interface: in, out
* Second-order low-pass filter with unity gain

R1 in 2 R1
R2 2 3 R2
C1 2 out C1
C2 3 0 C2
IOP 3 0 out

* Non-Inverting Amplifier
* Parameters: R1, R2
* Interface: in, out
* Gain = 1 + R2/R1

R1 2 0 R1
R2 2 out R2
IOP in 2 out

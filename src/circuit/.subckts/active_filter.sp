* Active filter with parameterized components
* Interface nodes: in, out
* Parameters: R1, R2, C1, C2

R1 in 2 1k
R2 2 3 1k
IOP 3 out out
C1 2 out 1u
C2 3 0 1u
